# Keil uVision project Project.uvprojx, settings and files
target STM32F3348-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F3348-Discovery
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3348_DISCO,ARM_MATH_CM4,__TARGET_FPU_VFP
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F3348-Discovery;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\DSP\Include
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f334x8.s
  group Drivers/BSP/STM32F3348-Discovery
    ../../../../../../Drivers/BSP/STM32F3348-Discovery/: stm32f3348_discovery.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi.c stm32f3xx_hal_flash.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_hrtim.c stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c uart.c adc.c timer.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c arm_rfft_fast_init_f32_mini.c
    ../../../../../../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../../../../../../Drivers/CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c arm_sin_cos_f32.c
    ../../../../../../Drivers/CMSIS/DSP/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../../../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c
    ../../../../../../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_sin_f32.c
    ../../../../../../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
software components: CMSIS:CORE 4.1.0
